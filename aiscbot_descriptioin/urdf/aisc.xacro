Commit message: updated

File: aiscbot_descriptioin/urdf/aisc.xacro (robot description, xacro)
@@ -9,5 +9,4 @@
 			<child link="laser"/>
 			<origin xyz="0 0 0.12" rpy="0.0 0.0 0.0"/>
-			<axis xyz="0 0 0"/>
 		</joint>
 	</robot>
